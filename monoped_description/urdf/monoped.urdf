Commit message: changed color to gray of biped and monoped

File: monoped_description/urdf/monoped.urdf (robot description, URDF)
Before this commit: robot monoped, 4 links, 3 joints
Links:
- link base: geometry visual box size=0.20 0.20 0.30
